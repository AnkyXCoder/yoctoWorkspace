IMAGE_INSTALL:append = " hello-service"
